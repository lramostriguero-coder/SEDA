# Keil uVision project timers servo.uvprojx, settings and files
target MiniDK2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: timers servo
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\Libraries\CM3\CoreSupport;.\Libraries\CM3\DeviceSupport
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ../Libraries/CM3/DeviceSupport/: startup_LPC17xx.s system_LPC17xx.c
  group User
    ../USER/: main.c
software components: CMSIS:CORE 5.6.0
